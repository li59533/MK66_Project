# Keil uVision project mk66_project.uvprojx, settings and files
target Normal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0VLQ18 NXP
  pack: NXP.MK66F18_DFP.11.0.1
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x10000000,0x040000) IROM2(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mk66_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app;..\mdl\rttviewer;..\mdl;..\bsp;..\fml;..\utilities
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group app
    ../app/: main.c
  group mdl
    ../mdl/: board.c
    ../mdl/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group bsp
    ../bsp/: bsp_adc.c bsp_clock.c bsp_e32.c bsp_flash.c bsp_led.c bsp_lmt01.c bsp_power.c bsp_systick.c bsp_tim.c bsp_uart.c bsp_conf.h
  group fml
    ../fml/: lnprotocol.c lnprotocol_std.c system_param.c version.c
  group uti
    ../utilities/: crc.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.1, Device:SDK Drivers:gpio 2.3.1, Device:SDK Drivers:i2c 2.0.6, Device:SDK Drivers:port 2.1.0, Device:SDK Drivers:rtc 2.1.0, Device:SDK Drivers:smc 2.0.4, Device:SDK Drivers:uart 2.1.6, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MK66F18_startup 1.0.0
